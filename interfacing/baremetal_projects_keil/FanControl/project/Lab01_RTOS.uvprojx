# Keil uVision project Lab01_RTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab01_RTOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\source\FreeRTOSv9.0.0\FreeRTOS\Source\include;..\source\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\source\Library\inc;..\source\code\files;..\source\code\config;..\source\lwip-1.3.2;..\source\lwip-1.3.2\src;..\source\lwip-1.3.2\src\api;..\source\lwip-1.3.2\src\arch;..\source\lwip-1.3.2\src\core;..\source\lwip-1.3.2\src\netif;..\source\lwip-1.3.2\src\LwIPEntry;..\source\lwip-1.3.2\src\core\ipv4;..\source\lwip-1.3.2\src\include\lwip;..\source\lwip-1.3.2\src\include\arch;..\source\lwip-1.3.2\src\include\netif;..\source\lwip-1.3.2\src\include\ipv4\lwip
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: STM32F10x.s
  group source
    ../source/code/files/: main.c
  group config
    ../source/code/config/: FreeRTOSConfig.h
  group library
    ../source/Library/src/: extint.c gpio.c i2c.c nvic.c timer.c usart.c watchdog.c can.c dma.c myspi.c pwm.c
  group RTOS
    ../source/FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../source/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../source/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
